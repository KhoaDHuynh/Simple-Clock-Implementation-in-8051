# Keil uVision project DongHo_DS1307.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DongHo_DS1307 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: DongHo_DS1307.a51
